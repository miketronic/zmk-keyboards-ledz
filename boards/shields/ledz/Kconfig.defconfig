## boards/shields/ledz/Kconfig.defconfig
```kconfig
# Copyright (c) 2024 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_ledz

config ZMK_KEYBOARD_NAME
    default "ledz"

endif
```
